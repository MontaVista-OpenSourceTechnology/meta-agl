require ${@bb.utils.contains('AGL_FEATURES', 'aglcore', 'weston_aglcore.inc', '', d)}
