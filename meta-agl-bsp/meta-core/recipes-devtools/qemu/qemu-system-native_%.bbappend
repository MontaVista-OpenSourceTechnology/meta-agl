do_configure[depends] += "ninja-native:do_populate_sysroot meson-native:do_populate_sysroot"
