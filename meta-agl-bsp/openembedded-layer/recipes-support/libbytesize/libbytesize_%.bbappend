# Change branch to main and update URL
SRC_URI = "git://github.com/storaged-project/libbytesize;branch=main;protocol=https"