do_configure:append:bbe() {
    echo 'gbm-format=rgb565' >> ${UNPACKDIR}/core.cfg
}
